Commit message: new low layer code modificaion(rollback)

File: robots/hydrus_xi/urdf/2d_opening.urdf (robot description, URDF)
Before this commit: robot opening, 0 links, 3 joints
Joints:
- removed joint frame_joint3
